COMPATIBLE_HOST:rpi:libc-glibc = "aarch64-poky-linux"
COMPATIBLE_MACHINE = "raspberrypi5"
